# Autodesk Inventor part: SR1_1
## iProperties
Created: 2008-11
Part Number: SR1_1
Document SubType Name: Blech
Designer: rselle
Author: rselle
## Feature names
1. Basis1
